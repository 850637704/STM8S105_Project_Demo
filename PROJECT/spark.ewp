# IAR project spark.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER; ..\HARDWARE\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: spark.hex
  ILINK.IlinkOutputFile: spark.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 1
  ICCSTM8.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: spark.srec
  group (top)
    ../: readme.txt
  group FWLIB
    ../FWLIB/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c
  group HARDWARE
    ../HARDWARE/: adc.c clock.c Create_Rand.c delay.c flash.c Gam_Mod_0.c Gam_Mod_1.c Gam_Mod_2.c Gam_Mod_3.c ht1621.c iwdg.c key.c led.c mymath.c tim2.c tim4.c yx5p.c
  group USER
    ../USER/: includes.h main.c stm8s_conf.h stm8s_interrupt.c
